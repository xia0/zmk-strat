## boards/shields/strat/Kconfig.shield
```kconfig
# No whitespace after the comma or in your keyboard name!
config SHIELD_STRAT
    def_bool $(shields_list_contains,strat)
```
